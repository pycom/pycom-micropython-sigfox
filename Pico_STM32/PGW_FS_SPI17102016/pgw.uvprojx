# Keil uVision project pgw.uvprojx, settings and files
target Pico (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: Pgw +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DTARGET_NUCLEO_F401RE -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DTARGET_STM32F401RE -DTARGET_STM32F4 -D__ASSERT_MSG --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE --split_sections -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -DARM_MATH_CM4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DDEVICE_I2C=1 -D__CORTEX_M4 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1475225460.12 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM -DTARGET_LIKE_MBED
  c include: .;mbed-dev;mbed-dev/hal;mbed-dev/hal/storage_abstraction;mbed-dev/api;mbed-dev/targets;mbed-dev/targets/hal;mbed-dev/targets/hal/TARGET_STM;mbed-dev/targets/hal/TARGET_STM/TARGET_STM32F4;mbed-dev/targets/hal/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE;mbed-dev/targets/cmsis;mbed-dev/targets/cmsis/TARGET_STM;mbed-dev/targets/cmsis/TARGET_STM/TARGET_STM32F4;mbed-dev/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE;mbed-dev/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD;mbed-dev/common;..\usb_test\Middlewares\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\usb_test\Inc\Inc;..\usb_test\Middlewares\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;.\SX1301HAL\inc
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-DARM_MATH_CM4,-D__CORTEX_M4,-D__MBED_CMSIS_RTOS_CM,-D__FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed-dev/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD/stm32f401xe.sct
  group TARGET_NUCLEO_F401RE
    mbed-dev/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.c hal_tick.h stm32f401xc.h stm32f4xx.h stm32f4xx_hal_conf.h system_stm32f4xx.c system_stm32f4xx.h
    mbed-dev/targets/hal/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h PortNames.h
  group TARGET_STM32F4
    mbed-dev/targets/hal/TARGET_STM/TARGET_STM32F4/: analogin_api.c analogout_api.c can_api.c common_objects.h device.h entropy_hardware_poll.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c mbed_overrides.c PeripheralPins.h pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    mbed-dev/targets/cmsis/TARGET_STM/TARGET_STM32F4/: stm32_hal_legacy.h stm32f4xx_hal.c stm32f4xx_hal.h stm32f4xx_hal_adc.c stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.c stm32f4xx_hal_can.h stm32f4xx_hal_cec.c stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.c stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.c stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.c stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.c stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.c stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.c stm32f4xx_hal_eth.h stm32f4xx_hal_flash.c stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.c stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.c stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.c stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.c stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.c stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.c stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nand.h stm32f4xx_hal_nor.c stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.c stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.c stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.c stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.c stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.c stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.c stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.c stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.c stm32f4xx_hal_spi.h stm32f4xx_hal_sram.c stm32f4xx_hal_sram.h stm32f4xx_hal_tim.c stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.c stm32f4xx_hal_uart.h stm32f4xx_hal_usart.c stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.c stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.c stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.c stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.c stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.c stm32f4xx_ll_usb.h
  group TOOLCHAIN_ARM_STD
    mbed-dev/targets/cmsis/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD/: startup_stm32f401xe.S sys.cpp
  group api
    mbed-dev/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h PlatformMutex.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SingletonPtr.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
  group cmsis
    mbed-dev/targets/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group common
    mbed-dev/common/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_gpio.c mbed_interface.c mbed_lp_ticker_api.c mbed_mem_trace.c mbed_pinmap_common.c mbed_rtc_time.cpp mbed_semihost_api.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_wait_api.c RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group hal
    mbed-dev/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
  group mbed
    ./: mbed_config.h
  group storage_abstraction
    mbed-dev/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group USB
    ../usb_test/Src/Src/: stm32f4xx_it.cpp usb_device.cpp usbd_cdc_if.cpp usbd_conf.cpp usbd_desc.cpp
    ../usb_test/Inc/Inc/: mxconstants.h stm32f4xx_hal_conf.h stm32f4xx_it.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h
  group MiddlewareUSB
    ../usb_test/Middlewares/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
    ../usb_test/Middlewares/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.cpp
    ../usb_test/Middlewares/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../usb_test/Middlewares/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.cpp usbd_ctlreq.cpp usbd_ioreq.cpp
  group SX1301
    ./: SX1301.cpp SX1301.h Registers1301.h
  group CmdUSB
    ./: CmdUSB.cpp CmdUSB.h
  group MAIN
    ../usb_test/: main.cpp
  group HALsX1301sRC
    ./SX1301HAL/src/: loragw_hal.cpp
    ./: loragw_reg_pgw.cpp
  group HALsX1301iNC
    ./SX1301HAL/inc/: loragw_aux.h loragw_fpga.h loragw_gps.h loragw_hal.h loragw_lbt.h loragw_radio.h loragw_reg.h
